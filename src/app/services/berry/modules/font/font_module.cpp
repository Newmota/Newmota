/*
  font_module.cpp - Berry embedded font class

  Copyright (C) 2026 Christian Baars and Newmota contributors

  This program is free software: you can redistribute it and/or modify
  it under the terms of the GNU General Public License as published by
  the Free Software Foundation, either version 3 of the License, or
  (at your option) any later version.
*/
/** @file font_module.cpp
 * @brief Draws UTF-8 text from tamp-compressed Latin-1 fonts into a pixmat.
 *
 * A font is divided into independently compressed blocks of glyphs. Small fonts are one block.
 * Large fonts keep the two most recently used blocks in the object's cache, which holds lowercase
 * ASCII completely; text needing more blocks decompresses them again.
 */

#include "services/berry/modules/font/font_module.h"

#include "services/berry/modules/font/font_tamp.h"
#include "services/berry/modules/pixmat/pixmat_module.h"

#include <array>
#include <cstddef>
#include <cstdint>
#include <cstring>

extern "C" {
#include "berry.h"
}

namespace {

/** @brief One embedded font, generated by tools/newmota/fonts.py. */
struct FontData {
    const char* name;
    std::uint8_t width, height, baseline, block_glyphs;
    std::uint16_t blocks;
    const std::uint16_t* offsets;
    const std::uint8_t* stream;
};

#include "newmota_fonts.h"

constexpr std::size_t kGlyphCount = 191;
constexpr std::size_t kMaximumSlots = 2;
constexpr std::uint32_t kReplacement = '?';

/** @brief Returns the row size of a font's glyphs in bytes. */
constexpr std::size_t stride(const FontData& font) {
    return (font.width + 7U) / 8U;
}

/** @brief Returns the size of one glyph in bytes. */
constexpr std::size_t glyph_bytes(const FontData& font) {
    return stride(font) * font.height;
}

/** @brief Returns how many blocks the object's cache holds. */
constexpr std::size_t slot_count(const FontData& font) {
    return font.blocks > 1U ? kMaximumSlots : 1U;
}

/** @brief Maps a code point to its glyph; anything outside Latin-1 draws a question mark. */
constexpr std::size_t glyph_index(std::uint32_t code) {
    if (code >= 0x20U && code <= 0x7eU)
        return code - 0x20U;
    if (code >= 0xa0U && code <= 0xffU)
        return code - 0xa0U + 0x5fU;
    return kReplacement - 0x20U;
}

/** @brief Decodes one code point; a malformed sequence is a question mark for one byte. */
std::uint32_t decode(const std::uint8_t*& at, const std::uint8_t* const end) {
    const auto lead = *at++;
    if (lead < 0x80U)
        return lead;
    int extra{};
    std::uint32_t code{}, minimum{};
    if ((lead & 0xe0U) == 0xc0U) {
        extra = 1;
        code = lead & 0x1fU;
        minimum = 0x80U;
    } else if ((lead & 0xf0U) == 0xe0U) {
        extra = 2;
        code = lead & 0x0fU;
        minimum = 0x800U;
    } else if ((lead & 0xf8U) == 0xf0U) {
        extra = 3;
        code = lead & 0x07U;
        minimum = 0x10000U;
    } else {
        return kReplacement;
    }
    if (end - at < extra)
        return kReplacement;
    for (int i = 0; i < extra; ++i) {
        if ((at[i] & 0xc0U) != 0x80U)
            return kReplacement;
        code = (code << 6U) | (at[i] & 0x3fU);
    }
    if (code < minimum || code > 0x10ffffU || (code >= 0xd800U && code <= 0xdfffU))
        return kReplacement;
    at += extra;
    return code;
}

/** @brief Stores an integer hidden field on the font instance. */
void member(bvm* const vm, const char* const name, const bint value) {
    be_pushint(vm, value);
    be_setmember(vm, 1, name);
    be_pop(vm, 1);
}

/** @brief Reads an integer hidden field of the font instance. */
int read_member(bvm* const vm, const char* const name) {
    be_getmember(vm, 1, name);
    const auto value = static_cast<int>(be_toint(vm, -1));
    be_pop(vm, 1);
    return value;
}

/** @brief Returns the font of an initialized instance. */
const FontData& font_of(bvm* const vm) {
    be_getmember(vm, 1, ".p");
    const auto* const font =
        be_iscomptr(vm, -1) ? static_cast<const FontData*>(be_tocomptr(vm, -1)) : nullptr;
    be_pop(vm, 1);
    if (font == nullptr)
        be_raise(vm, "runtime_error", "font is not initialized");
    return *font;
}

/** @brief The cache of one font object while text is drawn; nothing allocates meanwhile. */
struct Cache {
    bvm* vm;
    const FontData& font;
    std::uint8_t* data;
    std::array<int, kMaximumSlots> blocks;
    int last;

    /** @brief Returns the glyphs of a block, decompressing it into the older slot if needed. */
    const std::uint8_t* block(const int wanted) {
        const auto block_bytes = font.block_glyphs * glyph_bytes(font);
        const auto slots = static_cast<int>(slot_count(font));
        for (int slot = 0; slot < slots; ++slot)
            if (blocks[static_cast<std::size_t>(slot)] == wanted) {
                last = slot;
                return data + static_cast<std::size_t>(slot) * block_bytes;
            }
        const int slot = slots > 1 ? 1 - last : 0;
        auto* const out = data + static_cast<std::size_t>(slot) * block_bytes;
        // A failed load must not leave the slot naming its previous block.
        blocks[static_cast<std::size_t>(slot)] = -1;
        member(vm, slot ? ".s1" : ".s0", -1);
        const auto first = static_cast<std::size_t>(wanted) * font.block_glyphs;
        const auto glyphs =
            first + font.block_glyphs > kGlyphCount ? kGlyphCount - first : font.block_glyphs;
        const auto size = glyphs * glyph_bytes(font);
        const auto begin = font.offsets[wanted];
        const auto length = static_cast<std::size_t>(font.offsets[wanted + 1] - begin);
        if (!font_tamp_decompress(out, size, font.stream + begin, length))
            be_raise(vm, "runtime_error", "font data is damaged");
        blocks[static_cast<std::size_t>(slot)] = wanted;
        member(vm, slot ? ".s1" : ".s0", wanted);
        last = slot;
        return out;
    }
};

/** @brief `font(name)` selects an embedded font such as "8x16" and allocates its cache. */
int Init(bvm* const vm) {
    if (be_top(vm) != 2 || !be_isstring(vm, 2))
        be_raise(vm, "type_error", "font(name)");
    const auto* const name = be_tostring(vm, 2);
    const FontData* found{};
    for (const auto& font : kFonts)
        if (std::strcmp(font.name, name) == 0)
            found = &font;
    if (found == nullptr)
        be_raise(vm, "value_error", "font is not in this build");
    const auto size = slot_count(*found) * found->block_glyphs * glyph_bytes(*found);
    be_pushbytes(vm, nullptr, size);
    be_setmember(vm, 1, ".cache");
    be_pop(vm, 1);
    be_pushcomptr(vm, const_cast<FontData*>(found));
    be_setmember(vm, 1, ".p");
    be_pop(vm, 1);
    member(vm, ".s0", -1);
    member(vm, ".s1", -1);
    be_return_nil(vm);
}

/** @brief Returns the glyph cell width in pixels. */
int Width(bvm* const vm) {
    be_pushint(vm, font_of(vm).width);
    be_return(vm);
}

/** @brief Returns the glyph cell height in pixels. */
int Height(bvm* const vm) {
    be_pushint(vm, font_of(vm).height);
    be_return(vm);
}

/** @brief Returns the rows from the top of a cell to the baseline. */
int Baseline(bvm* const vm) {
    be_pushint(vm, font_of(vm).baseline);
    be_return(vm);
}

/** @brief Reads the string argument as a byte range. */
void text_range(
    bvm* const vm, const int index, const std::uint8_t*& begin, const std::uint8_t*& end) {
    if (!be_isstring(vm, index))
        be_raise(vm, "type_error", "font expects a string");
    begin = reinterpret_cast<const std::uint8_t*>(be_tostring(vm, index));
    end = begin + be_strlen(vm, index);
}

/** @brief `measure(text)` returns the width of UTF-8 text in pixels. */
int Measure(bvm* const vm) {
    if (be_top(vm) != 2)
        be_raise(vm, "type_error", "measure(text)");
    const auto& font = font_of(vm);
    const std::uint8_t *at{}, *end{};
    text_range(vm, 2, at, end);
    bint width{};
    while (at < end) {
        (void)decode(at, end);
        width += font.width;
    }
    be_pushint(vm, width);
    be_return(vm);
}

/** @brief `text(pixmat, text, x, y, color[, background])` draws and returns the next x. */
int Text(bvm* const vm) {
    const int argc = be_top(vm);
    if (argc != 6 && argc != 7)
        be_raise(vm, "type_error", "text(pixmat, text, x, y, color[, background])");
    const auto& font = font_of(vm);
    const std::uint8_t *at{}, *end{};
    text_range(vm, 3, at, end);
    for (int index = 4; index <= argc; ++index)
        if (!be_isint(vm, index))
            be_raise(vm, "type_error", "font expects integer coordinates and colors");
    const std::int64_t y = be_toint(vm, 5);
    auto pen = static_cast<std::int64_t>(be_toint(vm, 4));
    const auto color = static_cast<std::uint32_t>(be_toint(vm, 6));
    const auto background = argc == 7 ? static_cast<std::uint32_t>(be_toint(vm, 7)) : 0U;
    const auto target = newmota::pixmat_buffer(vm, 2, true);

    be_getmember(vm, 1, ".cache");
    std::size_t length{};
    auto* const data = static_cast<std::uint8_t*>(const_cast<void*>(be_tobytes(vm, -1, &length)));
    be_pop(vm, 1);
    if (data == nullptr || length < slot_count(font) * font.block_glyphs * glyph_bytes(font))
        be_raise(vm, "runtime_error", "font cache is not available");
    Cache cache{vm, font, data, {read_member(vm, ".s0"), read_member(vm, ".s1")}, 0};

    const bool row_visible = y < target.height && y + font.height > 0;
    while (at < end) {
        const auto index = glyph_index(decode(at, end));
        if (row_visible && pen < target.width && pen + font.width > 0) {
            const auto* const block = cache.block(static_cast<int>(index / font.block_glyphs));
            newmota::pixmat_draw_glyph(target,
                block + index % font.block_glyphs * glyph_bytes(font), font.width, font.height,
                static_cast<int>(stride(font)), pen, y, color, argc == 7 ? &background : nullptr);
        }
        pen += font.width;
    }
    be_pushint(vm, static_cast<bint>(pen));
    be_return(vm);
}

const bnfuncinfo methods[] = {{".p", nullptr}, {".cache", nullptr}, {".s0", nullptr},
    {".s1", nullptr}, {"init", Init}, {"width", Width}, {"height", Height}, {"baseline", Baseline},
    {"measure", Measure}, {"text", Text}, {nullptr, nullptr}};

} // namespace

namespace newmota {

bool install_font_module(bvm* const vm) {
    be_pushclass(vm, "font", methods);
    be_setglobal(vm, "font");
    be_pop(vm, 1);
    return true;
}

} // namespace newmota
